## src/drivers/ins/cv7/Kconfig
```kconfig
menuconfig DRIVERS_INS_CV7
	bool "cv7_ins"
	default n
	---help---
		Enable support for cv7_ins
```
